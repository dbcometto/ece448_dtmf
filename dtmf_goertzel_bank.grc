options:
  parameters:
    author: Ben Cometto
    category: '[DTMF]'
    generate_options: hb_qt_gui
    id: dtmf_goertzel_bank
    output_language: python
    title: DTMF Goertzel Decoder Bank
  states: {}

blocks:
- name: freqtable
  id: variable
  parameters:
    value: (697.0,770.0,852.0,941.0,1209.0,1336.0,1477.0,1633.0)
  states: {}
- name: thresh_absent
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: thresh_present
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    type: int
  states: {}
- name: blocks_and_xx_0_0
  id: blocks_and_xx
  parameters:
    type: int
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0_0_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[int,int],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.waiting_for_zero = False

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param

              if input_items[0] == 1:
                  output_items[0][:] = 1.0

              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: goertzel_fc_0
  id: goertzel_fc
  parameters:
    freq: freqtable[0]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_fc_0_0
  id: goertzel_fc
  parameters:
    freq: freqtable[1]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_fc_0_0_0
  id: goertzel_fc
  parameters:
    freq: freqtable[4]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_length
  id: parameter
  parameters:
    value: '1024'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '32000'
  states: {}

connections:
- [blocks_and_xx_0, '0', epy_block_0, '0']
- [blocks_and_xx_0_0, '0', epy_block_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_threshold_ff_0_0_0, '0']
- [blocks_float_to_int_0, '0', blocks_and_xx_0, '0']
- [blocks_float_to_int_0_0, '0', blocks_and_xx_0_0, '0']
- [blocks_float_to_int_0_0_0, '0', blocks_and_xx_0, '1']
- [blocks_float_to_int_0_0_0, '0', blocks_and_xx_0_0, '1']
- [blocks_threshold_ff_0, '0', blocks_float_to_int_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_int_0_0, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_float_to_int_0_0_0, '0']
- [goertzel_fc_0, '0', blocks_complex_to_mag_squared_0, '0']
- [goertzel_fc_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [goertzel_fc_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [pad_source_0, '0', goertzel_fc_0, '0']
- [pad_source_0, '0', goertzel_fc_0_0, '0']
- [pad_source_0, '0', goertzel_fc_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

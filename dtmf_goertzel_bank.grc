options:
  parameters:
    author: Ben Cometto
    category: '[DTMF]'
    generate_options: hb_qt_gui
    id: dtmf_goertzel_bank
    output_language: python
    title: DTMF Goertzel Decoder Bank
  states: {}

blocks:
- name: freqtable
  id: variable
  parameters:
    value: (697.0,770.0,852.0,941.0,1209.0,1336.0,1477.0,1633.0)
  states: {}
- name: thresh_absent
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: thresh_present
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_1
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_1
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_1_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_2
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_1
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_2
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_2_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_3
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_float_to_uchar_0_0_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_float_to_uchar_0_0_0_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_float_to_uchar_0_0_1
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_float_to_uchar_0_0_1_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_float_to_uchar_0_0_2
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_float_to_uchar_0_1
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '16'
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: blocks_threshold_ff_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: blocks_threshold_ff_0_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: blocks_threshold_ff_0_0_0_1
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: blocks_threshold_ff_0_0_1
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: gain
  id: parameter
  parameters:
    value: '5'
  states: {}
- name: goertzel_fc_0
  id: goertzel_fc
  parameters:
    freq: freqtable[0]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_fc_0_0
  id: goertzel_fc
  parameters:
    freq: freqtable[1]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_fc_0_0_0
  id: goertzel_fc
  parameters:
    freq: freqtable[4]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_fc_0_0_0_0
  id: goertzel_fc
  parameters:
    freq: freqtable[5]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_fc_0_0_0_0_0
  id: goertzel_fc
  parameters:
    freq: freqtable[7]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_fc_0_0_0_1
  id: goertzel_fc
  parameters:
    freq: freqtable[6]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_fc_0_0_1
  id: goertzel_fc
  parameters:
    freq: freqtable[3]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_fc_0_1
  id: goertzel_fc
  parameters:
    freq: freqtable[2]
    len: goertzel_length
    rate: samp_rate
  states: {}
- name: goertzel_length
  id: parameter
  parameters:
    hide: part
    value: '512'
  states: {}
- name: note_0
  id: note
  parameters:
    note: When updating, must manually edit output size to 16*1*1
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: ''
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '32000'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: freq0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: freq1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: freq4
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: freq5
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: freq7
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: freq6
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: freq3
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: freq2
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: '3'
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: '11'
  states: {}
- name: virtual_sink_1_0_1
  id: virtual_sink
  parameters:
    stream_id: '9'
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: '4'
  states: {}
- name: virtual_sink_1_1_0
  id: virtual_sink
  parameters:
    stream_id: '6'
  states: {}
- name: virtual_sink_1_1_0_0
  id: virtual_sink
  parameters:
    stream_id: '14'
  states: {}
- name: virtual_sink_1_1_1
  id: virtual_sink
  parameters:
    stream_id: '12'
  states: {}
- name: virtual_sink_1_2
  id: virtual_sink
  parameters:
    stream_id: '5'
  states: {}
- name: virtual_sink_1_2_0
  id: virtual_sink
  parameters:
    stream_id: '7'
  states: {}
- name: virtual_sink_1_2_0_0
  id: virtual_sink
  parameters:
    stream_id: '15'
  states: {}
- name: virtual_sink_1_2_1
  id: virtual_sink
  parameters:
    stream_id: '13'
  states: {}
- name: virtual_sink_1_3
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_sink_1_3_0
  id: virtual_sink
  parameters:
    stream_id: '10'
  states: {}
- name: virtual_sink_1_4
  id: virtual_sink
  parameters:
    stream_id: '8'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: freq0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: freq4
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: freq5
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: freq5
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: freq7
  states: {}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: freq7
  states: {}
- name: virtual_source_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: freq5
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: freq7
  states: {}
- name: virtual_source_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: freq7
  states: {}
- name: virtual_source_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: freq5
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: freq4
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: freq6
  states: {}
- name: virtual_source_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: freq6
  states: {}
- name: virtual_source_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: freq4
  states: {}
- name: virtual_source_0_0_2
  id: virtual_source
  parameters:
    stream_id: freq6
  states: {}
- name: virtual_source_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: freq6
  states: {}
- name: virtual_source_0_0_3
  id: virtual_source
  parameters:
    stream_id: freq4
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: freq0
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: freq1
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: freq1
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: freq3
  states: {}
- name: virtual_source_0_1_0_1
  id: virtual_source
  parameters:
    stream_id: freq3
  states: {}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: freq0
  states: {}
- name: virtual_source_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: freq2
  states: {}
- name: virtual_source_0_1_2
  id: virtual_source
  parameters:
    stream_id: freq2
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: freq1
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: freq1
  states: {}
- name: virtual_source_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: freq3
  states: {}
- name: virtual_source_0_2_1
  id: virtual_source
  parameters:
    stream_id: freq3
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: freq0
  states: {}
- name: virtual_source_0_3_0
  id: virtual_source
  parameters:
    stream_id: freq2
  states: {}
- name: virtual_source_0_4
  id: virtual_source
  parameters:
    stream_id: freq2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: '5'
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: '9'
  states: {}
- name: virtual_source_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: '13'
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: '6'
  states: {}
- name: virtual_source_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: '10'
  states: {}
- name: virtual_source_1_1_0_1
  id: virtual_source
  parameters:
    stream_id: '14'
  states: {}
- name: virtual_source_1_2
  id: virtual_source
  parameters:
    stream_id: '3'
  states: {}
- name: virtual_source_1_2_0
  id: virtual_source
  parameters:
    stream_id: '7'
  states: {}
- name: virtual_source_1_2_0_0
  id: virtual_source
  parameters:
    stream_id: '11'
  states: {}
- name: virtual_source_1_2_0_1
  id: virtual_source
  parameters:
    stream_id: '15'
  states: {}
- name: virtual_source_1_3
  id: virtual_source
  parameters:
    stream_id: '4'
  states: {}
- name: virtual_source_1_3_0
  id: virtual_source
  parameters:
    stream_id: '8'
  states: {}
- name: virtual_source_1_3_1
  id: virtual_source
  parameters:
    stream_id: '12'
  states: {}

connections:
- [blocks_and_xx_0, '0', virtual_sink_1, '0']
- [blocks_and_xx_0_0, '0', virtual_sink_1_0, '0']
- [blocks_and_xx_0_0_0, '0', virtual_sink_1_2, '0']
- [blocks_and_xx_0_0_0_0, '0', virtual_sink_1_2_0, '0']
- [blocks_and_xx_0_0_0_0_0, '0', virtual_sink_1_2_0_0, '0']
- [blocks_and_xx_0_0_0_1, '0', virtual_sink_1_2_1, '0']
- [blocks_and_xx_0_0_1, '0', virtual_sink_1_0_0, '0']
- [blocks_and_xx_0_0_1_0, '0', virtual_sink_1_0_0_0, '0']
- [blocks_and_xx_0_0_2, '0', virtual_sink_1_0_1, '0']
- [blocks_and_xx_0_1, '0', virtual_sink_1_1, '0']
- [blocks_and_xx_0_1_0, '0', virtual_sink_1_1_0, '0']
- [blocks_and_xx_0_1_0_0, '0', virtual_sink_1_1_0_0, '0']
- [blocks_and_xx_0_1_1, '0', virtual_sink_1_1_1, '0']
- [blocks_and_xx_0_2, '0', virtual_sink_1_3, '0']
- [blocks_and_xx_0_2_0, '0', virtual_sink_1_3_0, '0']
- [blocks_and_xx_0_3, '0', virtual_sink_1_4, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_threshold_ff_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_threshold_ff_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0_0, '0', blocks_threshold_ff_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_1, '0', blocks_threshold_ff_0_0_0_1, '0']
- [blocks_complex_to_mag_squared_0_0_1, '0', blocks_threshold_ff_0_0_1, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_threshold_ff_0_1, '0']
- [blocks_float_to_uchar_0, '0', virtual_sink_0, '0']
- [blocks_float_to_uchar_0_0, '0', virtual_sink_0_0, '0']
- [blocks_float_to_uchar_0_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_float_to_uchar_0_0_0_0, '0', virtual_sink_0_0_0_1, '0']
- [blocks_float_to_uchar_0_0_1, '0', virtual_sink_0_0_0_0, '0']
- [blocks_float_to_uchar_0_0_1_0, '0', virtual_sink_0_0_0_0_0, '0']
- [blocks_float_to_uchar_0_0_2, '0', virtual_sink_0_0_1, '0']
- [blocks_float_to_uchar_0_1, '0', virtual_sink_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', goertzel_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', goertzel_fc_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', goertzel_fc_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', goertzel_fc_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', goertzel_fc_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', goertzel_fc_0_0_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', goertzel_fc_0_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', goertzel_fc_0_1, '0']
- [blocks_streams_to_vector_0, '0', pad_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_uchar_0_0, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_float_to_uchar_0_0_0, '0']
- [blocks_threshold_ff_0_0_0_0, '0', blocks_float_to_uchar_0_0_1, '0']
- [blocks_threshold_ff_0_0_0_0_0, '0', blocks_float_to_uchar_0_0_1_0, '0']
- [blocks_threshold_ff_0_0_0_1, '0', blocks_float_to_uchar_0_0_0_0, '0']
- [blocks_threshold_ff_0_0_1, '0', blocks_float_to_uchar_0_0_2, '0']
- [blocks_threshold_ff_0_1, '0', blocks_float_to_uchar_0_1, '0']
- [goertzel_fc_0, '0', blocks_complex_to_mag_squared_0, '0']
- [goertzel_fc_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [goertzel_fc_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [goertzel_fc_0_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [goertzel_fc_0_0_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0_0, '0']
- [goertzel_fc_0_0_0_1, '0', blocks_complex_to_mag_squared_0_0_0_1, '0']
- [goertzel_fc_0_0_1, '0', blocks_complex_to_mag_squared_0_0_1, '0']
- [goertzel_fc_0_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_and_xx_0, '0']
- [virtual_source_0_0, '0', blocks_and_xx_0, '1']
- [virtual_source_0_0_0, '0', blocks_and_xx_0_0, '1']
- [virtual_source_0_0_0_0, '0', blocks_and_xx_0_0_0, '1']
- [virtual_source_0_0_0_0_0, '0', blocks_and_xx_0_0_0_0, '1']
- [virtual_source_0_0_0_0_0_0, '0', blocks_and_xx_0_0_0_0_0, '1']
- [virtual_source_0_0_0_0_1, '0', blocks_and_xx_0_0_0_1, '1']
- [virtual_source_0_0_0_1, '0', blocks_and_xx_0_0_1, '1']
- [virtual_source_0_0_0_1_0, '0', blocks_and_xx_0_0_1_0, '1']
- [virtual_source_0_0_0_2, '0', blocks_and_xx_0_0_2, '1']
- [virtual_source_0_0_1, '0', blocks_and_xx_0_1, '1']
- [virtual_source_0_0_1_0, '0', blocks_and_xx_0_1_0, '1']
- [virtual_source_0_0_1_0_0, '0', blocks_and_xx_0_1_0_0, '1']
- [virtual_source_0_0_1_1, '0', blocks_and_xx_0_1_1, '1']
- [virtual_source_0_0_2, '0', blocks_and_xx_0_2, '1']
- [virtual_source_0_0_2_0, '0', blocks_and_xx_0_2_0, '1']
- [virtual_source_0_0_3, '0', blocks_and_xx_0_3, '1']
- [virtual_source_0_1, '0', blocks_and_xx_0_0, '0']
- [virtual_source_0_1_0, '0', blocks_and_xx_0_0_0, '0']
- [virtual_source_0_1_0_0, '0', blocks_and_xx_0_0_0_0, '0']
- [virtual_source_0_1_0_0_0, '0', blocks_and_xx_0_0_0_0_0, '0']
- [virtual_source_0_1_0_1, '0', blocks_and_xx_0_0_0_1, '0']
- [virtual_source_0_1_1, '0', blocks_and_xx_0_0_1, '0']
- [virtual_source_0_1_1_0, '0', blocks_and_xx_0_0_1_0, '0']
- [virtual_source_0_1_2, '0', blocks_and_xx_0_0_2, '0']
- [virtual_source_0_2, '0', blocks_and_xx_0_1, '0']
- [virtual_source_0_2_0, '0', blocks_and_xx_0_1_0, '0']
- [virtual_source_0_2_0_0, '0', blocks_and_xx_0_1_0_0, '0']
- [virtual_source_0_2_1, '0', blocks_and_xx_0_1_1, '0']
- [virtual_source_0_3, '0', blocks_and_xx_0_2, '0']
- [virtual_source_0_3_0, '0', blocks_and_xx_0_2_0, '0']
- [virtual_source_0_4, '0', blocks_and_xx_0_3, '0']
- [virtual_source_1, '0', blocks_streams_to_vector_0, '0']
- [virtual_source_1_0, '0', blocks_streams_to_vector_0, '1']
- [virtual_source_1_0_0, '0', blocks_streams_to_vector_0, '5']
- [virtual_source_1_0_0_0, '0', blocks_streams_to_vector_0, '9']
- [virtual_source_1_0_0_1, '0', blocks_streams_to_vector_0, '13']
- [virtual_source_1_1, '0', blocks_streams_to_vector_0, '2']
- [virtual_source_1_1_0, '0', blocks_streams_to_vector_0, '6']
- [virtual_source_1_1_0_0, '0', blocks_streams_to_vector_0, '10']
- [virtual_source_1_1_0_1, '0', blocks_streams_to_vector_0, '14']
- [virtual_source_1_2, '0', blocks_streams_to_vector_0, '3']
- [virtual_source_1_2_0, '0', blocks_streams_to_vector_0, '7']
- [virtual_source_1_2_0_0, '0', blocks_streams_to_vector_0, '11']
- [virtual_source_1_2_0_1, '0', blocks_streams_to_vector_0, '15']
- [virtual_source_1_3, '0', blocks_streams_to_vector_0, '4']
- [virtual_source_1_3_0, '0', blocks_streams_to_vector_0, '8']
- [virtual_source_1_3_1, '0', blocks_streams_to_vector_0, '12']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

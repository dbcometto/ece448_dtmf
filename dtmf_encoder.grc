options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: dtmf_encoder
    output_language: python
    title: DTMF Encoder
  states: {}

blocks:
- name: char_per_sec
  id: variable
  parameters:
    value: '1'
  states: {}
- name: default_message
  id: variable
  parameters:
    value: '"12 34 56 78 90 AB CD *#"'
  states: {}
- name: goertzel_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: message
  id: variable
  parameters:
    value: '"12"'
  states: {}
- name: offtime
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ontime
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sleeptime
  id: variable
  parameters:
    value: '10'
  states: {}
- name: GRCdtmfgenerator_0
  id: GRCdtmfgenerator
  parameters:
    char_per_sec: char_per_sec
    dtmftext: message
    offtime: offtime
    ontime: ontime
    samp_rate: samp_rate
    sleeptime: sleeptime
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DTMF Signal"'
    type: float
  states: {}

connections:
- [GRCdtmfgenerator_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

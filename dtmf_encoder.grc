options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: dtmf_encoder
    output_language: python
    title: DTMF Encoder
  states: {}

blocks:
- name: char_per_sec
  id: variable
  parameters:
    value: '1'
  states: {}
- name: default_message
  id: variable
  parameters:
    value: '"12 34 56 78 90 AB CD *#"'
  states: {}
- name: goertzel_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: message
  id: variable
  parameters:
    value: '"12 45"'
  states: {}
- name: offtime
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ontime
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sleeptime
  id: variable
  parameters:
    value: '10'
  states: {}
- name: GRCdtmfgenerator_0
  id: GRCdtmfgenerator
  parameters:
    char_per_sec: char_per_sec
    dtmftext: message
    offtime: offtime
    ontime: ontime
    samp_rate: samp_rate
    sleeptime: sleeptime
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: byte
  states: {}
- name: dtmf_goertzel_bank_0
  id: dtmf_goertzel_bank
  parameters:
    gain: '3'
    goertzel_length: '1024'
    samp_rate: '32000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"DTMF Signal"'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    label1: '1'
    label2: '2'
    label3: '3'
    label4: '4'
    min: '0'
    nconnections: '4'
    type: byte
    update_time: '0.00001'
  states: {}

connections:
- [GRCdtmfgenerator_0, '0', dtmf_goertzel_bank_0, '0']
- [GRCdtmfgenerator_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_number_sink_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_number_sink_0, '1']
- [blocks_vector_to_streams_0, '2', qtgui_number_sink_0, '2']
- [blocks_vector_to_streams_0, '3', qtgui_number_sink_0, '3']
- [dtmf_goertzel_bank_0, '0', blocks_vector_to_streams_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

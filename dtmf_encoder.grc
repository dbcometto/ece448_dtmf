options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: dtmf_encoder
    output_language: python
    title: DTMF Encoder
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: GRCdtmfgenerator_0
  id: GRCdtmfgenerator
  parameters:
    char_per_sec: '0.8'
    dtmftext: '''12 34 56 78 90 AB CD *#'''
    offtime: '1'
    ontime: '5'
    samp_rate: samp_rate
    sleeptime: '100'
  states: {}
- name: goertzel_fc_0
  id: goertzel_fc
  parameters:
    freq: '697'
    len: '1'
    rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [GRCdtmfgenerator_0, '0', goertzel_fc_0, '0']
- [GRCdtmfgenerator_0, '0', qtgui_freq_sink_x_0, '0']
- [goertzel_fc_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

options:
  parameters:
    generate_options: qt_gui
    id: goertzel_test
    output_language: python
    title: Goertzel Test
  states: {}

blocks:
- name: goertzel_freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: signal_amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: signal_freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10000'
    value: '1000'
  states: {}
- name: thresh_absent
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: thresh_present
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: signal_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_present
    init: '0'
    low: thresh_absent
  states: {}
- name: goertzel_fc_0
  id: goertzel_fc
  parameters:
    freq: goertzel_freq
    len: '4096'
    rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Output"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', goertzel_fc_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_1, '0']
- [goertzel_fc_0, '0', blocks_complex_to_mag_squared_0, '0']
- [goertzel_fc_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

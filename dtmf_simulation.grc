options:
  parameters:
    generate_options: qt_gui
    id: dtmf_simulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: char_per_sec
  id: variable
  parameters:
    value: '1'
  states: {}
- name: default_message
  id: variable
  parameters:
    value: '"12 34 56 78 90 AB CD *#"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '5'
  states: {}
- name: goertzel_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: message
  id: variable
  parameters:
    value: '"12 45"'
  states: {}
- name: offtime
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ontime
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sleeptime
  id: variable
  parameters:
    value: '10'
  states: {}
- name: GRCdtmfgenerator_0
  id: GRCdtmfgenerator
  parameters:
    char_per_sec: char_per_sec
    dtmftext: message
    offtime: offtime
    ontime: ontime
    samp_rate: samp_rate
    sleeptime: sleeptime
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: byte
  states: {}
- name: dtmf_goertzel_bank_0
  id: dtmf_goertzel_bank
  parameters:
    gain: gain
    goertzel_length: goertzel_length
    samp_rate: samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='One Hot to Linear Coordinate Converter',   # will show up in GRC
                  in_sig=[np.uint8, np.uint8, np.uint8, np.uint8],
                  out_sig=[int]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              # convert presence values into one dimensional character coordinate

              # first, assign to readable values
              is697present = input_items[0][0]
              is712present = input_items[1][0]

              is1209present = input_items[2][0]
              is1336present = input_items[3][0]

              colCoord = 0*is697present + 1*is712present
              rowCoord = 0*is1209present + 1*is1336present

              if (is697present + is712present + is1209present + is1336present) == 0:
                  coordinate = -1
              else:
                  coordinate = rowCoord*2+colCoord

              # then, output the coordinate to GNU Radio
              output_items[0][:] = coordinate

              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"DTMF Signal"'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    label1: '1'
    label2: '2'
    label3: '3'
    label4: '4'
    min: '0'
    nconnections: '4'
    type: byte
    update_time: '0.00001'
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: '4'
    name: '"Index"'
    type: float
    update_time: '0.000001'
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://localhost:4444
    timeout: '100'
    type: int
  states: {}

connections:
- [GRCdtmfgenerator_0, '0', blocks_throttle2_0, '0']
- [blocks_int_to_float_0, '0', qtgui_number_sink_1, '0']
- [blocks_throttle2_0, '0', dtmf_goertzel_bank_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_streams_0, '0', epy_block_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_number_sink_0, '0']
- [blocks_vector_to_streams_0, '1', epy_block_0, '1']
- [blocks_vector_to_streams_0, '1', qtgui_number_sink_0, '1']
- [blocks_vector_to_streams_0, '2', epy_block_0, '2']
- [blocks_vector_to_streams_0, '2', qtgui_number_sink_0, '2']
- [blocks_vector_to_streams_0, '3', epy_block_0, '3']
- [blocks_vector_to_streams_0, '3', qtgui_number_sink_0, '3']
- [dtmf_goertzel_bank_0, '0', blocks_vector_to_streams_0, '0']
- [epy_block_0, '0', blocks_int_to_float_0, '0']
- [epy_block_0, '0', zeromq_push_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

options:
  parameters:
    generate_options: qt_gui
    id: dtmf_simulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: char_per_sec
  id: variable
  parameters:
    value: '5'
  states: {}
- name: default_message
  id: variable
  parameters:
    value: '"12 34 56 78 90 AB CD *#"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '5'
  states: {}
- name: goertzel_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: message
  id: variable
  parameters:
    value: '"123 A 456 B 789 C *0#D"'
  states: {}
- name: offtime
  id: variable
  parameters:
    value: '5'
  states: {}
- name: ontime
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: sleeptime
  id: variable
  parameters:
    value: '10'
  states: {}
- name: GRCdtmfgenerator_0
  id: GRCdtmfgenerator
  parameters:
    char_per_sec: char_per_sec
    dtmftext: message
    offtime: offtime
    ontime: ontime
    samp_rate: samp_rate
    sleeptime: sleeptime
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '16'
    type: byte
  states: {state: disabled}
- name: dtmf_goertzel_bank_0
  id: dtmf_goertzel_bank
  parameters:
    gain: gain
    goertzel_length: goertzel_length
    samp_rate: samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              self.vectorsize = 16
              gr.sync_block.__init__(
                  self,
                  name='One Hot to Linear Coordinate Converter',   # will show up in GRC
                  in_sig=[(np.uint8, 16)],
                  out_sig=[int]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              # self.example_param = example_param

          def work(self, input_items, output_items):
              # convert presence values into one dimensional character coordinate

              # first, assign to readable values
              # is697present = input_items[0][0]
              # is712present = input_items[1][0]

              # is1209present = input_items[2][0]
              # is1336present = input_items[3][0]

              # colCoord = 0*input_items[0][0] + 1*input_items[1][0] + 2*input_items[2][0] + 3*input_items[3][0]
              # rowCoord = 0*input_items[4][0] + 1*input_items[5][0]

              input_sum = 0
              coordinate = 0
              for n in range(0,len(input_items[0][0])):
                  input_sum += input_items[0][0][n]
                  coordinate += n*input_items[0][0][n]

              if input_sum == 0:
                  coordinate = 99

              # then, output the coordinate to GNU Radio
              output_items[0][:] = coordinate

              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: int(samp_rate/32000)
    taps: '1'
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"DTMF Signal"'
    type: float
  states: {}
- name: qtgui_number_sink
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    label1: '0'
    label2: '1'
    label3: '2'
    label4: '3'
    label5: '4'
    label6: '5'
    label7: '6'
    label8: '7'
    min: '0'
    name: '"Raw Bytes 0-7"'
    nconnections: '8'
    type: byte
    update_time: '0.00001'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    label1: '8'
    label2: '9'
    label3: '10'
    label4: '11'
    label5: '12'
    label6: '13'
    label7: '14'
    label8: '15'
    min: '0'
    name: '"Raw Bytes 8-15"'
    nconnections: '8'
    type: byte
    update_time: '0.00001'
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: '100'
    name: '"Index"'
    type: float
    update_time: '0.000001'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://localhost:4444
    timeout: '100'
    type: int
  states: {}

connections:
- [GRCdtmfgenerator_0, '0', blocks_throttle2_0, '0']
- [blocks_int_to_float_0, '0', qtgui_number_sink_1, '0']
- [blocks_throttle2_0, '0', dtmf_goertzel_bank_0, '0']
- [blocks_throttle2_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_number_sink, '0']
- [blocks_vector_to_streams_0, '1', qtgui_number_sink, '1']
- [blocks_vector_to_streams_0, '10', qtgui_number_sink_0, '2']
- [blocks_vector_to_streams_0, '11', qtgui_number_sink_0, '3']
- [blocks_vector_to_streams_0, '12', qtgui_number_sink_0, '4']
- [blocks_vector_to_streams_0, '13', qtgui_number_sink_0, '5']
- [blocks_vector_to_streams_0, '14', qtgui_number_sink_0, '6']
- [blocks_vector_to_streams_0, '15', qtgui_number_sink_0, '7']
- [blocks_vector_to_streams_0, '2', qtgui_number_sink, '2']
- [blocks_vector_to_streams_0, '3', qtgui_number_sink, '3']
- [blocks_vector_to_streams_0, '4', qtgui_number_sink, '4']
- [blocks_vector_to_streams_0, '5', qtgui_number_sink, '5']
- [blocks_vector_to_streams_0, '6', qtgui_number_sink, '6']
- [blocks_vector_to_streams_0, '7', qtgui_number_sink, '7']
- [blocks_vector_to_streams_0, '8', qtgui_number_sink_0, '0']
- [blocks_vector_to_streams_0, '9', qtgui_number_sink_0, '1']
- [dtmf_goertzel_bank_0, '0', blocks_vector_to_streams_0, '0']
- [dtmf_goertzel_bank_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_int_to_float_0, '0']
- [epy_block_0, '0', zeromq_push_sink_0, '0']
- [fir_filter_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
